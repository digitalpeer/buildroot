## package/rpio_pwm/Config.in
```kconfig
config BR2_PACKAGE_RPIO_PWM
	bool "RPIO PWM"
	help
	  DMA based PWM for Raspberry Pi

	  https://github.com/metachris/raspberrypi-pwm
```
